## base_external/package/aesd-socket/Config.in
```kconfig
config BR2_PACKAGE_AESD_SOCKET
    bool "aesd-socket"
    help
      A simple socket server app for AESD
```
